# Keil uVision project WashingMachine.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WashingMachine +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FreeRTOS_Libary\include;.\FreeRTOS_Libary\portable\RVDS\ARM_CM3;.\Libary\Inc;..\MayGiat_FuzzyMeowMeow
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c KieuGiat.c Fuzzy_Logic.c
  group Libary
    ./Libary/Src/: Delay_Timer.c font.c SPI.c ST7735_TFT_SPI.c Loadcell_HX711.c
  group RTOS
    ./FreeRTOS_Libary/: tasks.c queue.c list.c
    ./FreeRTOS_Libary/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS_Libary/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0
